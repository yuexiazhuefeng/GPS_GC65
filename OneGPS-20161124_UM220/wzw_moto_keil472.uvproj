# Keil uVision project wzw_moto_keil472.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F051C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: wzw_moto_keil472 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: .\Library;.\Library\CMSIS\Include;.\Library\CMSIS\ST\STM32F0xx\Include;.\Library\STM32F0xx_StdPeriph_Driver;.\Library\STM32F0xx_StdPeriph_Driver\inc;.\Library\STM32F0xx_StdPeriph_Driver\src;.\user;.\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group lib\
    ./Library/: stm32f0_discovery.c
    ./Library/CMSIS/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group user
    ./user/: SmsCmd.c stm32f0xx_it.c system_stm32f0xx.c gprs.c gps.c gsm.c LED.c main.c set_system_use_uart.c
    ./user/ADC/: adc.c
    ./user/lIS3DH/: lsm330dlc_driver.c i2c_lsm330.c
    ./user/usart1/: usart1.c
    ./user/WDG/: wdg.c
    ./user/FLASH/: ddi_Norflash.c
  group STM32F0xx_StdPeriph_Driver
    ./Library/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
